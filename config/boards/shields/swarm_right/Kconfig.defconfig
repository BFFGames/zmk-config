## config/boards/shields/swarm_right/Kconfig.defconfig
```kconfig
if SHIELD_SWARM_RIGHT

config ZMK_KEYBOARD_NAME
    default "Swarm Right"

endif
```
